# IAR project fase2_Pagano.ewp, settings and files
configuration fase2_Pagano (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334x8 ST STM32F334x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F334x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fase2_Pagano.srec
  ILINK.IlinkOutputFile: fase2_Pagano.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f334x8.s startup_stm32f334x8.s
  group Application/User
    ../Src/: main.c nRF24l01.c nRF24l01_defines.h pagano_app_library.c pagano_app_library.h pagano_dll_library.c pagano_dll_library.h pagano_library.h stm32f3xx_hal_msp.c stm32f3xx_it.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_gpio.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal.c stm32f3xx_hal_flash.c stm32f3xx_hal_i2c.c stm32f3xx_hal_pwr.c
